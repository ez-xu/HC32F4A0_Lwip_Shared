# Keil uVision project HC32F4A0_Lwip_V515.uvprojx, settings and files
target HC32F4A0_Lwip_V515 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F4A0_Lwip_V515 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,SOFTVER5_1_5
  c include: .\Project\Drivers\cmsis;.\Project\Drivers\cmsis\Device\HDSC\hc32f4xx\Include;.\Project\Drivers\cmsis\Include;.\Project\Drivers\hc32_ll_driver\inc;.\Project\Drivers\bsp\components\tca9539;.\Project\Drivers\bsp\ev_hc32f4a0_lqfp176;.\Project\lwip\src\include;.\Project\lwip\port;.\Project\FreeRTOS\Source\cmsis_rtos;.\Project\FreeRTOS\Source\include;.\Project\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\V5.1.5;.\V5.1.5\drv;.\Project\User;.\Project\User\source;.\Project\User\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  scatter file: .\V5.1.5\HC32F4A0_Lwip_V515.sct
  group Drives
    ./Project/Drivers/cmsis/: startup_hc32f4a0.s
    ./Project/Drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ./Project/Drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_eth.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_can.c hc32_ll_adc.c hc32_ll_rmu.c hc32_ll_rtc.c
    ./V5.1.5/drv/: drv_gpio.c drv_gpio.h drv_rtc.c drv_rtc.h
    ./Project/Drivers/bsp/components/tca9539/: tca9539.c
    ./Project/Drivers/bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_tca9539.c
  group Freertos
    ./Project/FreeRTOS/Source/cmsis_rtos/: cmsis_os.c
    ./Project/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Project/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Project/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lwip
    ./Project/lwip/src/api/: api_lib.c api_msg.c sockets.c err.c if_api.c netbuf.c netdb.c netifapi.c tcpip.c
    ./Project/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./Project/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./Project/lwip/src/netif/: ethernet.c
    ./Project/lwip/port/os/: sys_arch.c
  group User
    ./Project/User/: readme.txt parameter.c parameter.h initandset.c bcmu_tcp.c
    ./Project/User/source/: main.c app_ethernet.c ethernetif.c
